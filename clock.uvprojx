# Keil uVision project clock.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: clock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=6 wLevel=2
  c include: .\Hardware\ADC;.\Hardware\AT24C02;.\Hardware\CFG;.\Hardware\GPIO;.\Hardware\KEY;.\Hardware\MUSIC;.\Hardware\NRF24L01;.\Hardware\OLED;.\Hardware\OLED_NEW;.\Hardware\PWM;.\Hardware\TIME;.\Hardware;.\ZLG_GUI;.\Hardware\USART
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c
  group GUI
    ./ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
  group Device
    ./Hardware/ADC/: ADC.c
    ./Hardware/AT24C02/: at24c02.c
    ./Hardware/CFG/: i2c.c uart.c
    ./Hardware/GPIO/: GPIO.c
    ./Hardware/KEY/: Key.c
    ./Hardware/MUSIC/: music.c
    ./Hardware/OLED_NEW/: Oled_New.c
    ./Hardware/PWM/: pwm.c
    ./Hardware/TIME/: timer.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
